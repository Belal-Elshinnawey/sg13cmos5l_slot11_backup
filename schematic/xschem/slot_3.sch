v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/iopin.sym} -200 0 0 0 {name=p1 lab=vdd_3v3}
C {devices/iopin.sym} -200 -20 0 0 {name=p2 lab=vss_3v3}
C {devices/iopin.sym} -200 -40 0 0 {name=p3 lab=vdd_1v2}
C {devices/iopin.sym} -200 -60 0 0 {name=p4 lab=vss_1v2}
C {devices/iopin.sym} -200 -80 0 0 {name=p5 lab=vbias}
C {devices/iopin.sym} -200 -100 0 0 {name=p6 lab=ibias0}
C {devices/iopin.sym} -200 -120 0 0 {name=p7 lab=ibias1}
C {devices/iopin.sym} -200 -140 0 0 {name=p8 lab=s3_an[0:1]}
C {devices/iopin.sym} -200 -160 0 0 {name=p9 lab=s3_an_0_esd}
C {devices/iopin.sym} -200 -180 0 0 {name=p10 lab=analog_bus0}
C {devices/iopin.sym} -200 -200 0 0 {name=p11 lab=analog_bus1}
C {devices/iopin.sym} -200 -220 0 0 {name=p12 lab=analog_bus2}
C {devices/iopin.sym} -200 -240 0 0 {name=p13 lab=analog_bus3}
C {devices/ipin.sym} -200 -260 0 0 {name=p14 lab=enable}
C {devices/ipin.sym} -200 -280 0 0 {name=p15 lab=clk}
C {devices/ipin.sym} -200 -300 0 0 {name=p16 lab=reset}
C {devices/ipin.sym} -200 -320 0 0 {name=p17 lab=dig_in[23:0]}
C {devices/opin.sym} 200 0 0 0 {name=p18 lab=dig_out[11:0]}
