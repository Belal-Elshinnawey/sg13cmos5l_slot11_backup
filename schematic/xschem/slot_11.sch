v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l1 author=""}
C {timer_555_body.sym} 400 -300 0 0 {name=x1}
C {devices/iopin.sym} 40 -1600 0 0 {name=p_vss_1v2 lab=vss_1v2}
C {noconn.sym} 40 -1600 2 0 {name=l1}
C {devices/iopin.sym} 40 -1580 0 0 {name=p_s11_an0 lab=s11_an[0]}
C {devices/lab_pin.sym} 550 -380 2 0 {name=p_x1_reset_b sig_type=std_logic lab=s11_an[0]}
C {devices/iopin.sym} 40 -1560 0 0 {name=p_s11_an_0_esd lab=s11_an_0_esd}
C {noconn.sym} 40 -1560 2 0 {name=l2}
C {devices/iopin.sym} 40 -1540 0 0 {name=p_vbias lab=vbias}
C {noconn.sym} 40 -1540 2 0 {name=l3}
C {devices/ipin.sym} 40 -1520 0 0 {name=p_dig_in lab=dig_in[23:0]}
C {noconn.sym} 40 -1520 2 0 {name=l4}
C {devices/opin.sym} 40 -1500 0 0 {name=p_dig_out lab=dig_out[11:0]}
C {noconn.sym} 40 -1500 2 0 {name=l5}
C {devices/iopin.sym} 40 -1480 0 0 {name=p_ibias0 lab=ibias0}
C {devices/lab_pin.sym} 550 -320 2 0 {name=p_x1_ibias0 sig_type=std_logic lab=ibias0}
C {devices/iopin.sym} 40 -1460 0 0 {name=p_ibias1 lab=ibias1}
C {devices/lab_pin.sym} 550 -200 2 0 {name=p_x1_ibias1 sig_type=std_logic lab=ibias1}
C {devices/iopin.sym} 40 -1440 0 0 {name=p_analog_bus3 lab=analog_bus3}
C {devices/lab_pin.sym} 550 -300 2 0 {name=p_x1_trigger sig_type=std_logic lab=analog_bus3}
C {devices/iopin.sym} 40 -1420 0 0 {name=p_analog_bus2 lab=analog_bus2}
C {devices/lab_pin.sym} 550 -360 2 0 {name=p_x1_vctrl sig_type=std_logic lab=analog_bus2}
C {devices/iopin.sym} 40 -1400 0 0 {name=p_analog_bus1 lab=analog_bus1}
C {devices/lab_pin.sym} 550 -340 2 0 {name=p_x1_threshold sig_type=std_logic lab=analog_bus1}
C {devices/iopin.sym} 40 -1380 0 0 {name=p_analog_bus0 lab=analog_bus0}
C {devices/lab_pin.sym} 550 -400 2 0 {name=p_x1_set_b sig_type=std_logic lab=analog_bus0}
C {devices/iopin.sym} 40 -1360 0 0 {name=p_vdd_1v2 lab=vdd_1v2}
C {devices/lab_pin.sym} 550 -240 2 0 {name=p_x1_avdd1v2 sig_type=std_logic lab=vdd_1v2}
C {devices/iopin.sym} 40 -1340 0 0 {name=p_vss_3v3 lab=vss_3v3}
C {devices/lab_pin.sym} 550 -220 2 0 {name=p_x1_avss sig_type=std_logic lab=vss_3v3}
C {devices/iopin.sym} 40 -1320 0 0 {name=p_vdd_3v3 lab=vdd_3v3}
C {devices/lab_pin.sym} 550 -280 2 0 {name=p_x1_avdd sig_type=std_logic lab=vdd_3v3}
C {devices/ipin.sym} 40 -1300 0 0 {name=p_enable lab=enable}
C {noconn.sym} 40 -1300 2 0 {name=l6}
C {devices/ipin.sym} 40 -1280 0 0 {name=p_clk lab=clk}
C {noconn.sym} 40 -1280 2 0 {name=l7}
C {devices/ipin.sym} 40 -1260 0 0 {name=p_reset lab=reset}
C {noconn.sym} 40 -1260 2 0 {name=l8}
