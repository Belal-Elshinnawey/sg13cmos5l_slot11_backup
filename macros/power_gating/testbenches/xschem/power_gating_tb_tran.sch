** sch_path: macros/power_gating/testbenches/xschem/power_gating_tb_tran.sch
**.subckt power_gating_tb_tran
x1 DOUT SG_AVDD DVDD EG_IBIAS SG_DVDD AVDD IBIAS EG_AVDD ENA STDBY GND power_gating
VAVDD AVDD GND {AVDD}
VDVDD DVDD GND {DVDD}
IBIAS GND IBIAS {IBIAS}
VENA ENA GND PWL(0 0 10u 0 10.01u 1.2 20u 1.2 20.01u 0 50u 0 50.01u 1.2 60u 1.2 60.01u 0 70u 0)
VSTDBY STDBY GND PWL(0 0 30u 0 30.01u 1.2 40u 1.2 40.01u 0 50u 0 50.01u 1.2 60u 1.2 60.01u 0 70u 0)
Vmeas_ibias EG_IBIAS net1 0
.save i(vmeas_ibias)
VCOMPL net1 GND 1.0
**** begin user architecture code


.include ../../../netlist/pex/power_gating_magic_pex_3.spice
.param AVDD=3.3
.csparam AVDD=AVDD
.param DVDD=1.2
.csparam DVDD=DVDD
.param IBIAS=1u
.csparam IBIAS=IBIAS
.temp 27
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

tran 1n 70u
write @schname\.raw

* Plotting
plot ena stdby
plot eg_avdd sg_avdd
plot sg_dvdd
plot eg_ibias dout


* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/@schname\.txt v(ena) v(stdby) v(eg_avdd) v(sg_avdd) v(sg_dvdd)
+ v(eg_ibias) v(dout) i(vmeas_ibias)

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.end
