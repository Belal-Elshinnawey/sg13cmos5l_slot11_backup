v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l1 author=""}
C {resistor_leg.sym} 0 -800 0 0 {name=xA}
C {resistor_leg.sym} 0 -600 0 0 {name=xB}
C {resistor_leg.sym} 400 -800 0 0 {name=xC}
C {resistor_leg.sym} 400 -600 0 0 {name=xD}
C {devices/iopin.sym} 150 -850 2 1 {name=pio_pt lab=pt}
C {devices/lab_pin.sym} 550 -850 0 1 {name=lp_pt_c sig_type=std_logic lab=pt}
C {devices/iopin.sym} 150 -810 2 1 {name=pio_vdd lab=VDD}
C {devices/lab_pin.sym} 150 -610 0 1 {name=lp_vdd_b sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 550 -810 0 1 {name=lp_vdd_c sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 550 -610 0 1 {name=lp_vdd_d sig_type=std_logic lab=VDD}
C {devices/iopin.sym} 150 -830 0 0 {name=pio_vss lab=VSS}
C {devices/lab_pin.sym} 150 -630 2 0 {name=lp_vss_b sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 550 -830 2 0 {name=lp_vss_c sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 550 -630 2 0 {name=lp_vss_d sig_type=std_logic lab=VSS}
C {devices/iopin.sym} 150 -770 2 1 {name=pio_p1 lab=p1}
C {devices/lab_pin.sym} 550 -770 2 0 {name=lp_p1_c sig_type=std_logic lab=p1}
C {devices/iopin.sym} 150 -590 0 0 {name=pio_p2 lab=p2}
C {devices/lab_pin.sym} 550 -590 2 0 {name=lp_p2_d sig_type=std_logic lab=p2}
C {devices/iopin.sym} 150 -550 2 1 {name=pio_pb lab=pb}
C {devices/lab_pin.sym} 550 -550 0 1 {name=lp_pb_d sig_type=std_logic lab=pb}
C {devices/lab_pin.sym} 150 -750 0 1 {name=lp_nab_a sig_type=std_logic lab=n_ab}
C {devices/lab_pin.sym} 150 -650 0 1 {name=lp_nab_b sig_type=std_logic lab=n_ab}
C {devices/lab_pin.sym} 550 -750 0 1 {name=lp_ncd_c sig_type=std_logic lab=n_cd}
C {devices/lab_pin.sym} 550 -650 0 1 {name=lp_ncd_d sig_type=std_logic lab=n_cd}
C {devices/lab_pin.sym} 150 -790 2 0 {name=lp_a_p1 sig_type=std_logic lab=a_p1}
C {devices/lab_pin.sym} 150 -570 2 0 {name=lp_b_p2 sig_type=std_logic lab=b_p2}
C {devices/lab_pin.sym} 550 -790 2 0 {name=lp_c_p1 sig_type=std_logic lab=c_p1}
C {devices/lab_pin.sym} 550 -570 2 0 {name=lp_d_p2 sig_type=std_logic lab=d_p2}
