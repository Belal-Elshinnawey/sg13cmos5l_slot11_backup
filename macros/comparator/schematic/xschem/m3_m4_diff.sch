v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l1 author=""}
C {p1_4.sym} 0 -400 0 0 {name=xM3[15:0]}
C {p1_4.sym} 300 -400 0 0 {name=xM4[15:0]}
C {devices/iopin.sym} 20 -370 2 0 {name=pio_n1 lab=n1}
C {devices/lab_pin.sym} -20 -400 0 0 {name=lp_n1_g sig_type=std_logic lab=n1}
C {devices/lab_pin.sym} 280 -400 0 0 {name=lp_n1_g2 sig_type=std_logic lab=n1}
C {devices/iopin.sym} 320 -370 2 0 {name=pio_outx lab=outx}
C {devices/iopin.sym} 20 -430 2 0 {name=pio_avdd lab=avdd}
C {devices/lab_pin.sym} 20 -400 2 0 {name=lp_avdd_b1 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 320 -430 2 0 {name=lp_avdd_s2 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 320 -400 2 0 {name=lp_avdd_b2 sig_type=std_logic lab=avdd}
