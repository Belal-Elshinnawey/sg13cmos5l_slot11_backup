** sch_path: macros/schmitt_trigger_pullmid/verification/cace/templates/schmitt_trigger_pullmid_tb_tran_pex.sch
**.subckt schmitt_trigger_pullmid_tb_tran_pex
x1 DVDD AIN DOUT GND schmitt_trigger_pullmid_pex
XC1 AIN_SRC AIN cap_cmomf w=30.0e-6 l=75.0e-6 mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1
+ mm_ok=1
VAIN AIN_SRC GND SIN(0 0.5 12MEG)
VDVDD DVDD GND CACE{dvdd}
**** begin user architecture code


.include /foss/designs/sg13cmos5l_slot3_backup/macros/schmitt_trigger_pullmid/netlist/pex/schmitt_trigger_pullmid_magic_pex_3.spice
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-12 gmin=1e-12 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control

save all
set num_threads=16

tran 100p 5u

* V+/V-: value of AIN at the instant DOUT crosses its own midpoint, after
* the pull-mid network has settled (quarter of the run in).
meas tran v_plus FIND v(ain) WHEN v(dout)=CACE[0.5*CACE{dvdd}] FALL=1 TD=1.25u
meas tran v_minus FIND v(ain) WHEN v(dout)=CACE[0.5*CACE{dvdd}] RISE=1 TD=1.25u
let hysteresis = v_plus - v_minus

echo $&v_plus $&v_minus $&hysteresis > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_typ

**** end user architecture code
**.ends
.end
