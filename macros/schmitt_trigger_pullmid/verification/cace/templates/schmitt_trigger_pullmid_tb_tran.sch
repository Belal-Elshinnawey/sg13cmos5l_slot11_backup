** sch_path: macros/schmitt_trigger_pullmid/verification/cace/templates/schmitt_trigger_pullmid_tb_tran.sch
**.subckt schmitt_trigger_pullmid_tb_tran
x1 DVDD AIN DOUT GND schmitt_trigger_pullmid
XC1 AIN_SRC AIN cap_cmomf w=30.0e-6 l=75.0e-6 mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1
+ mm_ok=1
VAIN AIN_SRC GND SIN(0 0.5 12MEG)
VDVDD DVDD GND CACE{dvdd}
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-12 gmin=1e-12 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control

save all
set num_threads=16

tran 100p 5u

* V+/V-: value of AIN at the instant DOUT crosses its own midpoint, after
* the pull-mid network has settled (quarter of the run in).
meas tran v_plus FIND v(ain) WHEN v(dout)=CACE[0.5*CACE{dvdd}] FALL=1 TD=1.25u
meas tran v_minus FIND v(ain) WHEN v(dout)=CACE[0.5*CACE{dvdd}] RISE=1 TD=1.25u
let hysteresis = v_plus - v_minus

echo $&v_plus $&v_minus $&hysteresis > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_typ

**** end user architecture code
**.ends

* expanding   symbol:  schmitt_trigger_pullmid.sym # of pins=4
** sym_path: schmitt_trigger_pullmid.sym
** sch_path: schmitt_trigger_pullmid.sch
.subckt schmitt_trigger_pullmid SG_DVDD AIN DOUT VSS
*.iopin SG_DVDD
*.iopin VSS
*.ipin AIN
*.opin DOUT
Vmeas6 AIN net1 0
.save i(vmeas6)
XR1 SG_DVDD MID VSS rhigh w=0.5e-6 l=3.412e-05 m=1 b=0 mm_ok=1
XR2 MID VSS VSS rhigh w=0.5e-6 l=3.412e-05 m=1 b=0 mm_ok=1
XR3 net1 MID VSS rhigh w=0.5e-6 l=2.7172e-04 m=1 b=0 mm_ok=1
XC4 VSS SG_DVDD cap_cmomf w=30.0e-6 l=75.0e-6 mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1
+ mm_ok=1
XM4 DOUT net1 DLT VSS sg13_lv_nmos w=1u l=0.3u ng=1 m=1 mm_ok=1
XM5 DHT net1 SG_DVDD SG_DVDD sg13_lv_pmos w=1u l=0.3u ng=1 m=1 mm_ok=1
XM3 DOUT net1 DHT SG_DVDD sg13_lv_pmos w=1u l=0.3u ng=1 m=1 mm_ok=1
XM7 VSS DOUT DHT SG_DVDD sg13_lv_pmos w=1u l=0.3u ng=1 m=1 mm_ok=1
XM6 DLT net1 VSS VSS sg13_lv_nmos w=1u l=0.3u ng=1 m=1 mm_ok=1
XM8 SG_DVDD DOUT DLT VSS sg13_lv_nmos w=1u l=0.3u ng=1 m=1 mm_ok=1
.ends

.end
