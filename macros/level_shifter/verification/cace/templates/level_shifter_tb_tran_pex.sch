** sch_path: macros/level_shifter/verification/cace/templates/level_shifter_tb_tran_pex.sch
**.subckt level_shifter_tb_tran_pex
x1 AVDD LO_B DVDD LO HI GND HI_B level_shifter_pex
VLO LO GND PULSE(0 CACE{dvdd} 100u 0 0 100u 200u)
VDVDD DVDD GND CACE{dvdd}
VAVDD AVDD GND CACE{vdd}
**** begin user architecture code


.include /foss/designs/sg13cmos5l_slot3_backup/macros/level_shifter/netlist/pex/level_shifter_magic_pex_3.spice
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-12 gmin=1e-12 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control

save all
set num_threads=16

tran 10n 300u

meas tran tpd_rise TRIG v(lo) VAL=CACE[0.5*CACE{dvdd}] RISE=1 TARG v(hi) VAL=CACE[0.5*CACE{vdd}] RISE=1
meas tran tpd_fall TRIG v(lo) VAL=CACE[0.5*CACE{dvdd}] FALL=1 TARG v(hi) VAL=CACE[0.5*CACE{vdd}] FALL=1
meas tran tr_hi TRIG v(hi) VAL=CACE[0.1*CACE{vdd}] RISE=1 TARG v(hi) VAL=CACE[0.9*CACE{vdd}] RISE=1
meas tran tf_hi TRIG v(hi) VAL=CACE[0.9*CACE{vdd}] FALL=1 TARG v(hi) VAL=CACE[0.1*CACE{vdd}] FALL=1

echo $&tpd_rise $&tpd_fall $&tr_hi $&tf_hi > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}

**** end user architecture code
**.ends
.end
